# Keil uVision project iSO-STM32.uvprojx, settings and files
target uCOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uCOSIII +hex
  c flags: v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\..\App;..\..\Bsp;..\..\User;..\..\uCOS-III\Source;..\..\uCOS-III\Ports;..\..\uCOS-III\uC-CPU;..\..\uCOS-III\Cfg;..\..\uCOS-III\uC-LIB;..\..\Lib\CMSIS;..\..\Lib\FWlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ../../Lib/CMSIS/startup/: startup_stm32f10x_md.s
  group Lib
    ../../Lib/CMSIS/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
    ../../Lib/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../../User/: main.c
  group App
    ../../App/: app.c os_cfg.h app.h os_cfg_app.h
  group Bsp
    ../../Bsp/: bsp.c bsp_uart.c led_key.c
  group uC\Source
    ../../uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC\Ports
    ../../uCOS-III/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC\Lib
    ../../uCOS-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_cfg.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC\Cpu
    ../../uCOS-III/uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_cfg.h cpu_core.c cpu_core.h cpu_def.h
  group uC\Cfg
    ../../uCOS-III/Cfg/: os_app_hooks.c os_app_hooks.h
software components: CMSIS:CORE 5.1.2
