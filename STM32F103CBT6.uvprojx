# Keil uVision project STM32F103CBT6.uvprojx, settings and files
target TIM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103CBT6
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Lib\CM3\CoreSupport;.\Lib\CM3\DeviceSupport;.\Lib\STM32F10x_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Lib
    ./Lib/CM3/CoreSupport/: core_cm3.c
    ./Lib/CM3/DeviceSupport/: stm32f10x_it.c system_stm32f10x.c
    ./Lib/STM32F10x_StdPeriph_Driver/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Start
    ./Start/: startup_stm32f10x_md.s
  group User
    ./User/: main.c bsp_tim.c bsp_tim.h bsp_adc.c bsp_adc.h bsp_dma.c bsp_dma.h bsp_systick.c bsp_systick.h bsp_uart.c bsp_uart.h led_key.c led_key.h hc_sr04.c hc_sr04.h bsp_at24c02.h bsp_at24c02.c
